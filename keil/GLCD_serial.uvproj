# Keil uVision project GLCD_serial.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: GLCD_serial +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Group 1
    ../: main.c
    ../include/: 8051_UART.h g_lcd.h 8051_UART.c g_lcd.c
